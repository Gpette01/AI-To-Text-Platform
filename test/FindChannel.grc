options:
  parameters:
    author: ubuntulaptop
    generate_options: qt_gui
    id: FindChannel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: 200e3
    stop: 1000e6
    value: 446.09375e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass complex_threshold(gr.sync_block):\n    def __init__(self, low_threshold=1.0):\n        gr.sync_block.__init__(self,\n            name=\"complex_threshold\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64])\n        self.low_threshold = low_threshold\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # Apply threshold efficiently using numpy operations\n        magnitude = np.abs(in0)\n\n        # Zero the values below the low threshold\n        out[:] = np.where(magnitude >= self.low_threshold, in0, 0)\n\n        return len(output_items[0])\n\n"
    low_threshold: '0.19'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Filtered Real
    label2: Filtered Imaginary
    size: '1024'
    srate: samp_rate/5
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 0.0125e6
    freq0: fc
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_add_xx_0, '1']
- [epy_block_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '0', blocks_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
