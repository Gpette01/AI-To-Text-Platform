options:
  parameters:
    generate_options: qt_gui
    id: Thesis
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '22'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '10'
    max_dev: 5e3
    quad_rate: int(samp_rate/5)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '''hw:0,0'''
    samp_rate: '44100'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: +bw/2
    low_cutoff_freq: '-bw/2'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: window.WIN_KAISER
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: device
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass complex_threshold(gr.sync_block):\n    def __init__(self, low_threshold=1.0):\n        gr.sync_block.__init__(self,\n            name=\"Noise Threshold\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64])\n        self.low_threshold = low_threshold\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # Apply threshold efficiently using numpy operations\n        magnitude = np.abs(in0)\n\n        # Zero the values below the low threshold\n        out[:] = np.where(magnitude >= self.low_threshold, in0, 0)\n\n        return len(output_items[0])\n\n"
    low_threshold: '0.15'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport wave\nimport os\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):  # Inherits from gr.sync_block\n    \"\"\"WAV File Appender Block\"\"\"\n\n    def __init__(self, file='/app/file.wav'):  # default arguments only\n        \"\"\"Initialize the block with the file path\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='WAV File Appender',   # Will show up in GRC\n            in_sig=[np.float32],        # Input signature\n            out_sig=None                # No output\n        )\n        self.file = file\n        self.file_handle = None\n\n    def start(self):\n        \"\"\"Open the WAV file for appending or create it if it doesn't exist\"\"\"\n        if os.path.exists(self.file):\n            # Open existing WAV file in read/write binary mode without truncating\n            self.file_handle = open(self.file, 'rb+')\n            # Use wave module to read existing header\n            wav_reader = wave.open(self.file_handle, 'rb')\n            self.params = wav_reader.getparams()\n            self.n_frames = self.params.nframes\n            wav_reader.close()\n            # Move file pointer to the end of the data chunk\n            self.file_handle.seek(0, os.SEEK_END)\n        else:\n            # Create a new WAV file\n            self.file_handle = open(self.file, 'wb')\n            # Set parameters\n            n_channels = 1\n            sampwidth = 2  # 16 bits per sample\n            framerate = 48000\n            comptype = 'NONE'\n            compname = 'not compressed'\n            self.params = (n_channels, sampwidth, framerate, 0, comptype, compname)\n            # Write initial header\n            wav_writer = wave.open(self.file_handle, 'wb')\n            wav_writer.setparams(self.params)\n            wav_writer.close()\n            self.n_frames = 0\n        return True\n\n    def work(self, input_items, output_items):\n        \"\"\"Write the incoming audio data to the WAV file\"\"\"\n        in0 = input_items[0]\n        # Convert float32 data to int16\n        data = (in0 * 32767).astype(np.int16)\n        # Write the data to the file\n        self.file_handle.write(data.tobytes())\n        # Update the frame count\n        self.n_frames += len(data)\n        return len(in0)\n\n    def stop(self):\n        \"\"\"Update the WAV file header and close the file when the flowgraph stops\"\"\"\n        # Update the header with the new frame count\n        self.file_handle.seek(0)\n        wav_writer = wave.open(self.file_handle, 'rb+')\n        # Update nframes in the params\n        params = self.params._replace(nframes=self.n_frames)\n        wav_writer.setparams(params)\n        wav_writer.close()\n        # Close the file handle\n        self.file_handle.close()\n        return True\n\n"
    file: file
  states: {}
- name: fc
  id: parameter
  parameters:
    type: eng_float
    value: 446.03125e6
  states: {}
- name: file
  id: parameter
  parameters:
    type: str
    value: /home/ubuntulaptop/Desktop/distanceTest.wav
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 5e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    label1: Raw
    name: '"Band Pass"'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    label1: Raw
    name: '"Raw Data"'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5/10
    fc: '0'
    fftsize: '1024'
    label1: Audio
    name: '"Audio"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Filtered Real
    label2: Filtered Imaginary
    name: '"Demodulated Signal"'
    size: '1024'
    srate: samp_rate/5
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl="device'
    bb_gain0: '20'
    bw0: bw
    corr0: ppm
    dc_offset_mode0: '1'
    freq0: fc
    gain0: gain
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, '0', analog_nbfm_rx_0, '0']
- [epy_block_0, '0', analog_wfm_rcv_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
